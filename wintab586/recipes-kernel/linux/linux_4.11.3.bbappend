FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://defconfig \
"

COMPATIBLE_MACHINE = "wintab586"


